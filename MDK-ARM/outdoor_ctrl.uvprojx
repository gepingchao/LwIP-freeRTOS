# Keil uVision project outdoor_ctrl.uvprojx, settings and files
target outdoor_ctrl (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: outdoor_ctrl
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC
  c misc: --C99
  c include: ../Inc;                           ../Drivers/STM32F1xx_HAL_Driver/Inc;                           ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                           ../Drivers/CMSIS/Include;                           ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                        ../Middlewares/Third_Party/LwIP/src/include;                        ../Middlewares/Third_Party/LwIP/src/include/ipv4;                        ../Middlewares/Third_Party/LwIP/system;                        ../Middlewares/Third_Party/LwIP/src/include/ipv4/lwip;                        ../Middlewares/Third_Party/LwIP/src/include/lwip;                        ../Middlewares/Third_Party/LwIP/src/include/netif;                        ../Middlewares/Third_Party/LwIP/src/include/posix;                        ../Middlewares/Third_Party/LwIP/src/include/posix/sys;                        ../Middlewares/Third_Party/LwIP/src/netif/ppp;                        ../Middlewares/Third_Party/LwIP/system/arch;                      ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;                      ../Middlewares/Third_Party/FreeRTOS/Source/include;                      ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: gpio.c stm32f1xx_hal_timebase_TIM.c stm32f1xx_it.c main.c stm32f1xx_hal_msp.c lwip.c ethernetif.c freertos.c usart.c cJSON.c cpu.c CRC.c socket_lib.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc.c stm32f1xx_hal_flash.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_eth.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_uart.c
  group Application/MDK-ARM
    ./: startup_stm32f107xc.s
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: ppp.c md5.c ppp_oe.c randm.c lcp.c pap.c magic.c chap.c chpms.c vj.c ipcp.c fsm.c auth.c
    ../Middlewares/Third_Party/LwIP/src/core/: def.c sys.c dns.c raw.c udp.c stats.c mem.c tcp_out.c memp.c tcp.c tcp_in.c dhcp.c init.c netif.c pbuf.c lwip_timers.c
    ../Middlewares/Third_Party/LwIP/src/api/: err.c netbuf.c tcpip.c api_lib.c netdb.c sockets.c api_msg.c netifapi.c
    ../Middlewares/Third_Party/LwIP/src/netif/: slipif.c etharp.c
    ../Middlewares/Third_Party/LwIP/src/core/snmp/: asn1_enc.c mib2.c msg_out.c asn1_dec.c msg_in.c mib_structs.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip_addr.c inet_chksum.c icmp.c inet.c ip_frag.c ip.c autoip.c igmp.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c event_groups.c list.c queue.c tasks.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 4.1.0
